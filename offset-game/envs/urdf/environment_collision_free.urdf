Commit message: Added vision sensor

File: offset-game/envs/urdf/environment_collision_free.urdf (robot description, URDF)
Before this commit: robot environment, 1 links, 0 joints
Links:
- link buildings: geometry visual mesh filename=./meshes/benning_new.obj
